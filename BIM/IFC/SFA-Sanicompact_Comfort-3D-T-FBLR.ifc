Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2011-04-14T15:16:09
Written by: Autodesk Revit Architecture 2011 - 1.0
Made in: 20100326_1700(x64)

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, 默认
RefLatitude: 42, 12, 46, 800000; RefLongitude: -71, -1, -58, -800000; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
PSet_Revit_其他 - 项目发布日期: Issue Date; 项目状态: Project Status; 客户姓名: Owner; 项目地址: Enter address here; 项目名称: Project Name; 项目编号: Project Number

# IfcBuildingStorey, Level 1
Elevation: 0 mm
PSet_Revit_标识数据 - 名称: Level 1
PSet_Revit_限制条件 - 立面: 0 mm
PSet_Revit_Type_图形 - 线宽: 1; 颜色: 0; 线型图案: Centre; 符号: M_Level Head - Circle; 端点 1 处的默认符号: no; 端点 2 处的默认符号: yes
PSet_Revit_Type_限制条件 - 基面: 0
PSet_Revit_Type_尺寸标注 - 自动计算房间高度: no; 计算高度: 1200 mm

# IfcBuildingElementProxy: SFA010006-3D-T-FBLR, SFA010006-3D-T-FBLR:SFA010006-3D-T-FBLR:SFA010006-3D-T-FBLR:108867
In: Level 1
PSet_Revit_限制条件 - 标高: Level 1; 主体: 标高 : Level 1; 偏移: 0 mm; 与邻近图元一同移动: no
PSet_Revit_阶段化 - 创建的阶段: New Construction
